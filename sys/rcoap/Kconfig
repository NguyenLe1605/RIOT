## sys/rcoap/Kconfig
```kconfig
config MODULE_RCOAP
    bool
    prompt "rcoap" 
    default y 
    select  MODULE_RUST_RIOTMODULES
```
